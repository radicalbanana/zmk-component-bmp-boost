## boards/arm/bmp_boost/Kconfig.board
```kconfig
# SPDX-License-Identifier: MIT

config BOARD_BMP_BOOST
    bool "BMP Boost"
    depends on SOC_NRF52840_QIAA
```
